# Keil uVision project IPMC.uvproj, settings and files
target IPMC (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: IPMC +hex
  AfterMake: fromelf.exe --bin -o ./Output/IPMC.bin ./Output/IPMC.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\INC;..\LIB\STM32F2xx_StdPeriph_Driver\inc;..\LIB\CMSIS\Device\ST\STM32F2xx\Include;..\SYS;..\LIB\CMSIS\Include;..\RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000400 size 0x1fc00
  group APP
    ../APP/: app.c
  group SRC
    ../SRC/: comp_uart.c startup.c comp_gpio.c serve_amf.c comp_fish.c olupd.c ymodem.c flash_if.c
  group SYS
    ../SYS/: system_stm32f2xx.c startup_stm32f2xx.s
  group LIB
    ../LIB/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_usart.c stm32f2xx_rcc.c stm32f2xx_gpio.c misc.c stm32f2xx_syscfg.c stm32f2xx_flash.c
target BOOTLOADER (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: as above
  output: hBooter +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x7ff
